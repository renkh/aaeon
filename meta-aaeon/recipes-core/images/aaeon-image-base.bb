SUMMARY = "AAEON Base OS Image"
LICENSE = "MIT"

require recipes-core/images/aaeon-image-common.inc

IMAGE_FEATURES += "read-only-rootfs"
